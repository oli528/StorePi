File: Block Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: PSU added
Other:
- note added: "0v"
